# IAR project simple_timer_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\simple_timer; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: simple_timer_pca10056.hex
  ILINK.IlinkOutputFile: simple_timer_pca10056.out
  ILINK.IlinkIcfFile: simple_timer_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/simple_timer/: app_simple_timer.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_timer.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
