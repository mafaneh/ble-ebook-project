# IAR project ble_app_hids_keyboard_nfc_pairing_pca10040_s132.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\..\components\libraries\experimental_mpu; ..\..\..\..\..\..\..\components\libraries\experimental_ringbuf; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\experimental_stack_guard; ..\..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\..\components\libraries\usbd\config; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t; ..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_app_hids_keyboard_nfc_pairing_pca10040_s132.hex
  ILINK.IlinkOutputFile: ble_app_hids_keyboard_nfc_pairing_pca10040_s132.out
  ILINK.IlinkIcfFile: ble_app_hids_keyboard_nfc_pairing_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/ecc/: ecc.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_micro-ecc
    ../../../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_NFC
    ../../../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_oob_advdata/: nfc_ble_oob_advdata.c
    ../../../../../../../components/nfc/ndef/connection_handover/common/: nfc_ble_pair_common.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_lib/: nfc_ble_pair_lib.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_msg/: nfc_ble_pair_msg.c
    ../../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_iar.a
    ../../../../../../../components/nfc/ndef/text/: nfc_text_rec.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
