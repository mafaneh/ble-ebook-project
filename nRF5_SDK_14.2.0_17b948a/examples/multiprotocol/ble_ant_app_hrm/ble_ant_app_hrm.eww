<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s332\iar\ble_ant_app_hrm_pca10040_s332.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\d52_starterkit\s332\iar\ble_ant_app_hrm_d52_starterkit_s332.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s332_uart\iar\ble_ant_app_hrm_pca10040_s332_uart.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\d52_starterkit\ser_332_uart\iar\ble_ant_app_hrm_d52_starterkit_s332_uart.ewp</path>
  </project>  <batchBuild/>
</workspace>